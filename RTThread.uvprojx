# Keil uVision project RTThread.uvprojx, settings and files
target RTThread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: RTThread
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src\rtt\bsp;.\src\rtt\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ./src/user/: main.c
  group rtt/port
    ./src/rtt/libcpu/arm/cortex-m4/: cpuport.c
  group rtt/source
    ./src/rtt/src/: thread.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
